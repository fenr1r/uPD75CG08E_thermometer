# Repository fenr1r/uPD75CG08E_thermometer

File README.md:

# uPD75CG08E_thermometer

詳細は以下をご覧ください。

https://vita-brevis.hatenablog.com/entry/2026/03/12/023651

## ファイルに残存している設計の誤り

- 回路図：SOとDIの接続ポートが逆
- 基板：フットプリント割り当てミスにより、LM336-2.5の2ピンと3ピンが逆

## KiCad design KiCad/KiCad_uPD75CG08E.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad

Connections:
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

Parts:
C7, C9: 0.1u; C_Disc_D4.7mm_W2.5mm_P5.00mm
C8: 1u; C_Disc_D4.7mm_W2.5mm_P5.00mm
C10: 47p; C_Disc_D4.7mm_W2.5mm_P5.00mm
D3, D4: 1S1588; D_DO-35_SOD27_P7.62mm_Horizontal
J2: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J3: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
JP1, JP2, JP3: SJ_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP4: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R2: 5.1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 1.8k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R6: 20k +/-1%; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7, R8: 100k +/-1%; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9: 2.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R11: 5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R12, R14: 4.3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R13: 27k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: 5k Trim (Bouns 3296W); Potentiometer_Bourns_3296W_Vertical
RV2: 10k Trim (Bouns 3296W); Potentiometer_Bourns_3296W_Vertical
U3: uPC616C; DIP-8_W7.62mm_LongPads
U4: LM358; DIP-8_W7.62mm_LongPads
U5: LM336-2.5; TO-92_Inline
U6: uPD7001; DIP-16_W7.62mm_Socket_LongPads

Connections:
+5VA: D3.1 (K), J3.1, R9.1; also elsewhere on the board
+5VD: J3.3, JP4.2 (B), R12.1, R14.1; also elsewhere on the board
+12V: C7.1, J2.1, R3.1, U4.8 (V+); also elsewhere on the board
/MPU Sheet/DI: U6.3 (SI); also elsewhere on the board
/MPU Sheet/SO: R14.2, U6.5 (SO); also elsewhere on the board
/MPU Sheet/~#CS: U6.6 (~CS); also elsewhere on the board
/MPU Sheet/~#EOC: R12.2, U6.1 (~EOC); also elsewhere on the board
/MPU Sheet/~SCK: U6.4 (~SCK); also elsewhere on the board
GND: C7.2, C8.2, C9.2, C10.2, D4.2 (A), JP1.2 (B), JP2.2 (B), JP3.2 (B), R4.1, R7.1, RV2.1, U3.1 (V-), U4.4 (V-), U4.5 (+), U5.2 (A), U6.9 (VSS), U6.14 (AGND); also elsewhere on the board
unnamed: C8.1, R10.1, R11.2
unnamed: D3.2 (A), D4.1 (K), R8.1, R10.2, U4.1
unnamed: J2.2, R2.1
unnamed: C9.1, J3.2, U6.16 (VDD)
unnamed: JP1.1 (A), U6.13 (A3)
unnamed: JP2.1 (A), U6.12 (A2)
unnamed: JP3.1 (A), U6.11 (A1)
unnamed: JP4.1 (A), U6.2 (DL)
unnamed: R3.2, RV1.1
unnamed: R4.2, RV1.3
unnamed: R5.2, RV1.2
unnamed: R6.2, U3.2 (Output), U3.3 (Input)
unnamed: R2.2, U3.4 (V+)
unnamed: R5.1, R7.2, U4.3 (+)
unnamed: R6.1, R8.2, U4.2 (-)
unnamed: U4.6 (-), U4.7
unnamed: R9.2, RV2.3, U5.3 (K), U6.15 (VREF)
unnamed: RV2.2, U5.1 (REF)
unnamed: R11.1, U6.10 (A0)
unnamed: R13.1, U6.7 (CL0)
unnamed: C10.1, R13.2, U6.8 (CL1)

Notes on the sheet:
ADC f_{s}=7kHz (140us)
6.85V-10[mV/K]×T[K]
2.49V
減算回路 (G = 5)
6.85V (6.55V-7.25V)
LPF f_{c}=15.8Hz
4.22V (=6.85V-2.63V)
LM336のピン配置確認すること！（TL431の流用）

Parts:
C11: 33p; C_Disc_D7.5mm_W5.0mm_P7.50mm
C12, C13: 0.1u; C_Disc_D4.7mm_W2.5mm_P5.00mm
D5: 1S1588; D_DO-35_SOD27_P7.62mm_Horizontal; not fitted
D6, D7, D8, D9: TLO1002; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J4: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
J5, J6, J7: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
JP5: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
R15, R16: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R17: 82k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R18, R19, R20, R21: 510; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RN1: 3.3k_SIL04; R_Array_SIP5
SW2, SW3: SW_Push; SW_PUSH_6mm
SW4: SW_DIP_x04; SW_DIP_SPSTx04_Slide_9.78x12.34mm_W7.62mm_P2.54mm
U7: uPD75CG08E; DIP-40_W15.24mm_LongPads
U8, U9, U10: HDSP-0861; DIP-8_W15.24mm_Socket_LongPads

Connections:
+5VD: C12.1, C13.1, D5.1 (K), R18.1, R19.1, R20.1, R21.1, SW2.2, SW3.2, SW4.1, SW4.2, SW4.3, SW4.4, U7.20 (VDD), U8.7 (Vcc), U9.7 (Vcc), U10.7 (Vcc); also elsewhere on the board
/MPU Sheet/DI: J4.7; also elsewhere on the board
/MPU Sheet/SO: J4.5; also elsewhere on the board
/MPU Sheet/~#CS: J6.1, U7.31 (P5_{0}); also elsewhere on the board
/MPU Sheet/~#EOC: J7.1, U7.27 (P6_{0}); also elsewhere on the board
/MPU Sheet/~SCK: J4.3; also elsewhere on the board
GND: C11.1, C13.2, J4.1, R15.2, R16.2, RN1.1 (common), U7.39 (V_{SS}), U7.40 (X1), U8.6 (GND), U9.6 (GND), U10.6 (GND); also elsewhere on the board
unnamed: C12.2, D5.2 (A), R15.1, SW2.1, U7.18 (RESET)
unnamed: D6.2 (A), R18.2
unnamed: D6.1 (K), U7.10 (P3_{0})
unnamed: D7.2 (A), R19.2
unnamed: D7.1 (K), U7.11 (P3_{1})
unnamed: D8.2 (A), R20.2
unnamed: D8.1 (K), U7.12 (P3_{2})
unnamed: D9.2 (A), R21.2
unnamed: D9.1 (K), U7.13 (P3_{3})
unnamed: J4.2, U7.23 (P0_{0}/INT0)
unnamed: J4.4, U7.24 (P0_{1}/~SCK)
unnamed: J4.6, U7.25 (P0_{2}/SO)
unnamed: J4.8, U7.26 (P0_{3}/SI)
unnamed: J5.1, U7.35 (P4_{0})
unnamed: J5.2, U7.36 (P4_{1})
unnamed: J5.3, U7.37 (P4_{2})
unnamed: J5.4, U7.38 (P4_{3})
unnamed: J6.2, U7.32 (P5_{1})
unnamed: J6.3, U7.33 (P5_{2})
unnamed: J6.4, U7.34 (P5_{3})
unnamed: J7.2, U7.28 (P6_{1})
unnamed: J7.3, U7.29 (P6_{2})
unnamed: J7.4, U7.30 (P6_{3})
unnamed: JP5.1 (A), U9.4 (DP)
unnamed: JP5.3 (B), U10.4 (DP)
unnamed: JP5.2 (C), U7.5 (P2_{3})
unnamed: RN1.2 (R1), SW4.8, U7.9 (P1_{3})
unnamed: RN1.3 (R2), SW4.7, U7.8 (P1_{2})
unnamed: RN1.4 (R3), SW4.6, U7.7 (P1_{1})
unnamed: RN1.5 (R4), SW4.5, U7.6 (P1_{0})
unnamed: C11.2, R17.2, U7.19 (CL1)
unnamed: R17.1, U7.21 (CL2)
unnamed: R16.1, SW3.1, U7.22 (INT1)
unnamed: U7.2 (P2_{0}/~PSTB), U8.5 (LATCH_EN)
unnamed: U7.3 (P2_{1}/PTOUT), U9.5 (LATCH_EN)
unnamed: U7.14 (P7_{0}), U8.8 (INPUT_1), U9.8 (INPUT_1), U10.8 (INPUT_1)
unnamed: U7.15 (P7_{1}), U8.1 (INPUT_2), U9.1 (INPUT_2), U10.1 (INPUT_2)
unnamed: U7.16 (P7_{2}), U8.2 (INPUT_4), U9.2 (INPUT_4), U10.2 (INPUT_4)
unnamed: U7.17 (P7_{3}), U8.3 (INPUT_8), U9.3 (INPUT_8), U10.3 (INPUT_8)
unnamed: U7.4 (P2_{2}), U10.5 (LATCH_EN)

Parts:
C1: 100uF 25V; CP_Radial_D8.0mm_P3.80mm
C2, C4: 0.1u; C_Disc_D4.7mm_W2.5mm_P5.00mm; not fitted
C3: 0.1u; C_Disc_D4.7mm_W2.5mm_P5.00mm
C5, C6: 100u 16V; CP_Radial_D7.5mm_P2.50mm
D2: TLG1002; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F1: Polyfuse 0.5A; C_Disc_D4.7mm_W2.5mm_P5.00mm
J1: Barrel_Jack_Switch; BarrelJack_Horizontal
R1: 510; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: BP5293-50; TO-220-3_Vertical
U2: L7805; TO-252-3_TabPin2

Connections:
+5VA: C5.1, U2.3 (OUT); also elsewhere on the board
+5VD: C4.1, C6.1, R1.2, U1.3 (OUT); also elsewhere on the board
+12V: C1.1, C2.1, C3.1, F1.2, U1.1 (IN), U2.1 (IN); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D2.1 (K), J1.2, J1.3, U1.2 (GND), U2.2 (GND); also elsewhere on the board
unnamed: D2.2 (A), R1.1
unnamed: F1.1, J1.1

Board: 2 copper layers, 77.0 x 100.0 mm, 75 parts (2 on the bottom side), 72 nets.
